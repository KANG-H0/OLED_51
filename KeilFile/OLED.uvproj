# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Code/: I2C.c I2C.h main.c OLED.c OLED.h OLEDFont.h PictureBMP.h
